# Repository krayon/pinball-OPP (continued)

## KiCad design Kicad/1019-BallyIntf/1019.kicad_pcb

Board: 2 copper layers, 100.0 x 100.0 mm, 28 parts (1 on the bottom side), 96 nets.

Parts:
A3J1: CONN_9; 00_th1x9x156-lock
A3J2, A3J5: CONN_15; 00_th1x15x156-lock
A3J3: CONN_25; 00_th1x25x100-lock
A4J2: CONN_15; 00_th1x15x100-lock
A4J3: CONN1X16; 00_th1x16x100-lock
A5J1, A5J3: CONN_28; 00_th1x28x100-lock
P1, P2, P3, P4, P5, P6: CONN_8; 00_th1x8x100-lock
P7, P8, P9, P10, P15: CONN2X3MOLEX; 00_th2x3x4.2mm_cheap
P11, P12, P13, P14: TST; 00_mtg_hole-2-56
P16: CONN_4; 00_th1x4x100-lock
P17, P18: CONN1X16; 00_th1x16x100-lock
P19: CONN2X2PCP4MB; 00_th2x2x4.2mm_cheap
VAL: REF; opp_logo_backsilk

Connections:
+12V: P19.3, P19.4
/LFLIP: A3J1.8, P9.1
/LFLIPSW: A3J2.2, P16.1
/RFLIP: A3J1.9, P9.2
/RFLIPSW: A3J2.1, P16.2
GND: A3J3.3, A3J3.10, A3J3.18, A3J3.19, A3J3.20, A3J3.21, A3J3.22, A3J3.23, A3J3.24, P7.3, P7.6, P8.3, P8.6, P9.3, P9.6, P10.3, P10.6, P15.3, P15.6, P19.1, P19.2
unnamed: A3J2.5, P10.1
unnamed: A3J2.10, P10.2
unnamed: A3J2.12, P10.4
unnamed: A3J2.11, P10.5
unnamed: A3J2.6, A3J5.8, P8.1
unnamed: A3J5.9, P8.2
unnamed: A3J5.10, P8.5
unnamed: A3J1.5, P9.4
unnamed: A3J5.15, P7.4
unnamed: A3J1.3, A3J2.4, P15.1
unnamed: A3J5.11, P8.4
unnamed: A3J5.12, P7.1
unnamed: A3J5.13, P7.2
unnamed: A3J5.14, P7.5
unnamed: A5J3.11, P4.7
unnamed: A5J3.1, P4.1
unnamed: A5J3.2, P4.2
unnamed: A5J3.3, P4.3
unnamed: A5J3.4, P4.4
unnamed: A5J3.9, P4.5
unnamed: A5J3.10, P4.6
unnamed: A5J3.12, P4.8
unnamed: A5J3.13, P5.1
unnamed: A5J3.14, P5.2
unnamed: A5J1.18, P3.2
unnamed: A5J1.19, P3.3
unnamed: A5J1.24, P3.4
unnamed: A5J1.25, P3.5
unnamed: A5J1.26, P3.6
unnamed: A5J1.27, P3.7
unnamed: A5J1.28, P3.8
unnamed: A5J3.22, P6.2
unnamed: A5J3.23, P6.3
unnamed: A5J3.24, P6.4
unnamed: A5J3.25, P6.5
unnamed: A5J3.26, P6.6
unnamed: A5J3.27, P6.7
unnamed: A5J1.23, P6.8
unnamed: A5J3.21, P6.1
unnamed: A5J3.15, P5.3
unnamed: A5J3.16, P5.4
unnamed: A5J3.17, P5.5
unnamed: A5J3.18, P5.6
unnamed: A5J3.19, P5.7
unnamed: A5J3.20, P5.8
unnamed: A3J2.8, P15.4
unnamed: A3J5.7, P15.2
unnamed: A3J2.15, P15.5
unnamed: A3J1.2, A3J2.9, P9.5
unnamed: A5J1.17, P3.1
unnamed: A5J1.12, P2.4
unnamed: A5J1.13, P2.5
unnamed: A5J1.14, P2.6
unnamed: A5J1.15, P2.7
unnamed: A5J1.16, P2.8
unnamed: A5J1.9, P2.1
unnamed: A5J1.10, P2.2
unnamed: A5J1.11, P2.3
unnamed: A5J1.8, P1.8
unnamed: A5J1.1, P1.1
unnamed: A5J1.2, P1.2
unnamed: A5J1.3, P1.3
unnamed: A5J1.4, P1.4
unnamed: A5J1.5, P1.5
unnamed: A5J1.6, P1.6
unnamed: A5J1.7, P1.7
unnamed: A4J3.9, P18.9
unnamed: A4J3.10, P18.10
unnamed: A4J3.11, P18.11
unnamed: A4J3.12, P18.12
unnamed: A4J3.13, P18.13
unnamed: A4J3.14, P18.14
unnamed: A4J3.15, P18.15
unnamed: A4J3.16, P18.16
unnamed: A4J3.2, P18.1
unnamed: A4J3.3, P18.2
unnamed: A4J3.1, P18.8
unnamed: A4J2.4, P17.4
unnamed: A4J2.1, P17.1
unnamed: A4J2.2, P17.2
unnamed: A4J2.3, P17.3
unnamed: A4J2.5, P17.5
unnamed: A4J2.15, P17.16
unnamed: A4J2.11, P17.12
unnamed: A4J2.12, P17.13
unnamed: A4J2.13, P17.14
unnamed: A4J2.14, P17.15
unnamed: A4J2.10, P17.11
unnamed: A4J2.8, P17.9
unnamed: A4J2.9, P17.10

## Commit log (part)

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2012-07-27 Initial check-in
2012-10-31 Updated flash burn file to combine PROMs, added green PROMs to repository. Removed pause at end of flash burn so all burns would happen without user intervention.
2012-11-27 Updated silkscreen.
2012-12-04 Added code for display driver firmware (1008). Added a boot indication LED, current limit resistor, and rs232 header support to the board.
2012-12-07 Remove extra file.
2012-12-21 Changed serial transmit to use TDRE bit to increase transmit. Debugger sets processors to run at 8MHz bus clock. This could be increased to 10MHz in the future if necessary. Change addressing of card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
2013-01-15 Initial check-in of Java host controller. This code is just a frame that contains a short video running on the backglass LCD, and four player's scores, and the beginning of the serial interface to th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
2013-01-30 Oops, missed the video.
2013-02-07 Finished initial simplerules.txt file. Starting to code parsing engine.
2013-02-10 More updates to the parsing engine. Finished up to VARIABLES.
2013-02-18 Added batch file in lib to switch to run on 64 bit machines.
2013-03-12 Added 2nd char lookup table since two digits being driven by PCA9655 are driven slightly differently (bit 4 and 6 are swapped). Added another blank to char lookup tables to match defines. Changed i2c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
2013-03-29 More parsing, current error includes not parsing subquantities properly in if statements.
2013-09-11 Display changes: Add LED debugging for errors including i2c errors, blanking. Refresh all digits every 1 second. Upped to rev 00.00.05.
    HostCtl changes: Added three screen sizes instead of two. Add -title so titlebar can be used to move the window and debug. 64 bit dlls are the default.
2014-01-05 Added solenoid wiring diagram to interface document. (Now in Docs directory) Fixed RS232 interface pinout match solenoid and input cards. Added build.bat to create zip files for each project. Added b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
2014-02-02 Move the python script from being a prototype to the real code. Split the files out so that they functionality is contained within modules. Only bug fix is play the sounds more quickly when a key is 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
2014-04-13 Added INP_BRD_CFG and SOL_BRD_CFG which is used to configure the boards during startup.
2014-04-28 Added LED thread and LED update. Fixed rotate code. Changed position of some of the bits and display order for debug displays. Fix LED inlane code when ball is started.
2014-05-19 Added Comms state and strings to CommIntf so debugger can print current states of communications. GameData.commState now stores current state of the comms. Removed SPECIAL_PLAY and INLANE_COMPLETE st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
2014-06-05 Added RulesData.SCORE_HEIGHT so user can set height (in pixels) of displays. Added RulesData.SCORE_DISP_POS so user can place displays on screen. Each point marks the center of the display. The first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
2014-07-14 Finished inpBitNames.py, ledBitNames.py generation. Parse variables, indexed variables, sound and video.
2014-09-06 Small code updates to fix PinBrdGui.py with correct passed parameters. Added playfield rewire document.
2014-10-04 Fixes found since PyLint installed. General cleanup of GenPyCode and PinballFramework. Cleaned up init to use __init__. Updated imports to only use necessary objects. Added start of procChains.py fil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
2015-01-29 First cut of createRulesData.py. Removed most of the extra code since now storing all information in a single file for solenoids, inputs boards, etc. The information isn't split across the rulesData.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
2015-03-04 Remove code in PROCESS_CHAINS of ss3rules.txt that isn't currently processed by GenPyCode. Change clock and latch parallel port bits to match interface board in incandDrvTest.py. Remove -invert suppo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
2015-03-12 Update font file. Original font file did not work on XP because the size in the ttf was incorrect. The font file has been swapped for one that is correct.
2015-03-22 Fixed solenoid kicks in pinball framework. Added kicks for when games starts and balls end.
2015-05-12 Jackpot available mode now happens after a mode is completed. Added some constants such as CONST_ALL_INLANES to make code look cleaner. Remove submodes in CustomFunc. (Now only used the ones containe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
2015-06-13 Added callouts Joe provided. Added command to initial input card configuration. Added new standard function to set input card cfg.
2015-06-30 Replaced upper left pop with new solenoid that needs more kick. Clean up blinking LEDs at end of balls. Clear stateProg when entering/exiting modes. Fix target practice pop bumper selection. Fix trac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
2015-07-02 Increase volume of ballDrainOrgan.wav.
2015-07-07 Fix kickout hole sound. Should now only play sound in normal mode so mode callouts are clearer.
2015-07-25 SS3 presentation slides for Pintastic.
2015-07-31 Fix labeling issue on the incandescent board.
2015-09-21 Added Creator test project to interface with Neopixels. This is a work in progress and currently does not work. It uses a timer to kick off Neopixel processing every 20ms, and an SCB configured as SP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
2015-10-07 Updated brdIntf.odt document to include new Gen2 commands. These include the Neopixel serial commands. Added new python project to calculate CRC8s. Since Gen2 hardware has added error checking in the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
2015-12-10 Much improved input/solenoid board processing. Optimized to match 32 bit architecture. Now code is located in digital.c which does both input and solenoid processing. Cleaned up data structures to re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
2015-12-28 Added Commands.txt which gives example commands for easy cut/paste. Make it so only fast or slow incand blinking can be configured at once. Fix incand drive to match low side driver. Incand and Neo c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
2016-01-09 Bunch of code starting to bring SS3 over to MPF.
2016-02-11 Added cyflash (based off cyflash vers 1.06 found at pypi). Nick Johnson wrote the original code and full kudos to him. I merely modified the code to work with the PSoC4 where it uses a simple twos co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
2016-04-04 Creator: Added isr_spi.c/isr_uart.c which includes changes necessary for OPP ISRs.
    Python/Gen2Test:
    Added support for using configuration files for configuration instead of using structures built into Gen2Test.py Python file. Added standard cfgFile.py, joeCfg.py and mdCfg.py(mono-drop).
2016-05-03 1014, Incandescent through-hole board: Swapped to cheaper through-hole connector. Added copper board revision. Panel-1014: Added panellization of the board. Added MPF documentation on how to use OPP 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
2016-05-14 Updated Gen2Board.ods which now has a sheet that generates a parts list that can be ordered from Mouser. Added a testCfg.py that makes testing boards easier. (Wing 0 is incandescent wing, wing 1 is s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
2016-05-15 Added AH and KB to Gen2Board.ods/pdf.
2016-05-24 Added column to Gen2Board.ods/pdf to mark when packages shipped.
2016-07-10 Remove extra Creator project: CypBldrBLinkLED. Bootloader project is now contained within the Gen2 project. Added Set Serial Num/Get Serial Num command examples to Commands.txt. Default configuration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
2016-08-03 Removed Python/IncandTest since it is no longer needed with Gen2 hardware.
2016-08-24 Add better error reporting for Gen2Test.py. Updated version to rev 00.00.06
2016-11-08 Added newly generated files to PinballFramework/SS3. Fixed bug in procInpCards where only one bit was being reported in the inpBitNames.py file.
2016-12-11 More updates to bring so PinballFramework works with Gen2 cards. Framework is currently running and can play full games again. There are some bugs, but it will be easier to test on the real machine. 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
2017-01-08 More fixes for the pinball framework. At this point, games can be started, and score can be added. Games also end properly. Current issue is that solenoid status bits that are reported as one-shots a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
2017-03-11 Adding ss3BrdxCfg.py files for programming the configuration. Not sure why I never checked these in before. They are the updated versions for running 24V power supply.
2017-04-11 Updates to Gen2Test to support switch matrices. Firmware changes necessary with absolutely no testing. Beginning of rules file for Dolly retheme. Added windows flag so people using non-windows platfo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
2017-05-04 Updated brdIntf.odt/brdIntf.pdf to correct pinout documentation for solenoid wing board.
2017-06-02 GenPyCode: Fix procSolCards to accept CFG_SOL_USE_MTRX_AUTO_CLR
    PinballFramework: Add CFG_SOL_USE_MTRX_AUTO_CLR to rs232Intf.py. Fix solBitNames.py generation when using CFG_SOL_USE_MTRX_AUTO_CLR flag. Default debug frame to pulse switches for matrix inputs (sinc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
    VH: Start adding actual VH rules. Well, you can start a game and that's about it at this point. Rename functions in a more standard way.
2017-06-09 Added jukebox mode for Van Halen. Added retry timers for saucer kickout.
2017-07-04 Added presentation documents for Pintastic 2017.
    Updated Van Halen rules functions.
2017-10-11 Adding necessary Creator files missed in last check-in. For unknown reasons, the build will always fail and cause Creator a long time to come back. After it does come back, simply doing a clean and b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
2017-11-06 Added code to create pinball groups. Added viewmodel which displays groups for each of the meets. Removed extra action menus that didn't really do anything.
2018-01-25 Added new 1019-SolPlankG2. Board contains 8 solenoid drivers on a single board plus the interface connections. Haven't bothered panellizing it yet. Remove unused Creator/TestProj. Remove Kicad links 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
2018-04-18 SolPlank: Increase via size to meet DFM minimum. Update build.bat to save to 1019.zip. Add build_notes.txt to describe setting up Kicad libraries, and creating Gerbers. Add 1019.zip for ease of order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
    IncandPlank: Increase via size to meet DFM minimum. Update build.bat to save to 1020.zip. Add build_notes.txt to describe setting up Kicad libraries, and creating Gerbers. Add 1019.zip for ease of or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
    VH: Last updates grabbed from machine before sending to Joe.
2018-10-13 OPP Firmware (version 0.3.0.1): Add CAN_CANCEL flag to allow cancelling of initial kick pulse with a solenoid. Update to PSOC creator 4.2.
2018-11-17 Arduino: Fix some bogs in original NanoOPP.ino. First version of NanoBareOPP.ino which is bare metal programming of two solenoid wings.
2019-11-02 Rev 1.0.0.3 of OPP firmware: Remove rev 1.0.0.2 of firmware which didn't work. Corrected code to rewrite clearing of solenoids continuously during idles.
2019-12-29 Rev 1.0.1.3 of OPP Stm32 firmware:
    Fix PA14 and PA2 issues. Shift was in wrong direction causing PA14 to overwrite PA2.
2020-02-25 Kicad: Some zip files had multiple copies of copper layers because 7zip can store multiple files of the same names with different dates. Cleared out Gerber directories and regenerated all files.
2020-03-28 OPP STM32 version 2.0.0.2: Add initial pattern configuration for serial LEDs. Update documentation. Clean up implementation of pixel configuration.
2020-08-09 OPP STM32 version 2.0.0.6: Update NeoPixel process where fade calculation is done on a per byte basis. This removes the 32 fade record restriction at the cost of more processing and more memory. Test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
2021-02-07 Python: Add SendLed.py testing program to Gen2Test folder.
2021-03-16 OPP STM32 version 2.1.0.1: Add PB2 status LED. Switch read input sense of active low switch matrix and revert back to reverse column numbering. Reduce white wood lamp matrix test mode to 50% intensit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
