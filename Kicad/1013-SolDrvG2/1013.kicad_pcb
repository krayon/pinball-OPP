# Repository krayon/pinball-OPP

## KiCad design Kicad/1013-SolDrvG2/1013.kicad_pcb

Parts:
P1: TST
P2, P3, P5: CONN_4; Manufacturer PN 68001-436HLF
P4: CONN2X3MOLEX
P6: CONN_8
P10: SPADE_187; Manufacturer PN 1285
Q1, Q2, Q3, Q4: MOSFET_N; Manufacturer PN IRL540NPBF
R1: 0
R2, R3, R4, R5: 100K

Connections:
+5V: P2.3, P3.3
+12V1: P2.2, P3.2
/P0: P5.1, P6.1
/P1: P5.2, P6.2
/P2: P5.3, P6.3
/P3: P5.4, P6.4
/P4: P6.5, Q1.G, R2.2
/P5: P6.6, Q2.G, R3.2
/P6: P6.7, Q3.G, R4.2
/P7: P6.8, Q4.G, R5.2
GND: P2.4, P3.4, R1.1, R2.1, R3.1, R4.1, R5.1
GNDPWR: P2.1, P3.1, P4.3, P4.6, P10.1, P10.2 (PM), Q1.S, Q2.S, Q3.S, Q4.S, R1.2
unnamed: P4.4, Q4.D
unnamed: P4.1, Q1.D
unnamed: P4.2, Q2.D
unnamed: P4.5, Q3.D

Board: 2 copper layers, 44.4 x 20.3 mm, 17 parts (0 on the bottom side), 16 nets.

Other parts of the board:
VAL: REF; opp_logo_backsilk

## KiCad design Kicad/1019-SolPlankG2/1019.kicad_pcb

Parts:
J1: Conn_02x06_Top_Bottom; 00_th2x6x4.2mm_cheap
J2: Conn_01x22; Pin_Header_Straight_1x22_Pitch2.54mm
P1, P2, P3, P4: TST; 00_mtg_hole-2-56
P5, P6: CONN_4X2; Pin_Header_Straight_2x04_Pitch2.54mm
P7: CONN_4; 00_th1x4x100-lock; Manufacturer PN 68001-436HLF
P8: CONN_8; 00_th1x8x100-lock
P10: SPADE_187; 00_th1x2x200; Manufacturer PN 1285
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: MOSFET_N; 00_to220_vert_gds; Manufacturer PN IRL540NPBF
R1, R12: 0; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R2, R3, R4, R5, R6, R7, R8, R9: 100K; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R10, R11: 480; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical

Connections:
+5V: J2.22, P5.7, P6.7, P7.4
+12V1: P5.8, P6.8
/P0.0: J2.5, P8.1
/P0.1: J2.6, P8.2
/P0.2: J2.7, P8.3
/P0.3: J2.8, P8.4
/P0.4: J2.9, Q8.G, R9.2
/P0.5: J2.10, Q7.G, R8.2
/P0.6: J2.11, Q6.G, R7.2
/P0.7: J2.12, Q5.G, R6.2
/P1.0: J2.13, P8.5
/P1.1: J2.14, P8.6
/P1.2: J2.15, P8.7
/P1.3: J2.16, P8.8
/P1.4: J2.17, Q4.G, R5.2
/P1.5: J2.18, Q3.G, R4.2
/P1.6: J2.19, Q2.G, R3.2
/P1.7: J2.20, Q1.G, R2.2
/P4.0: J2.1, P5.3, P7.2
/P4.1: J2.2, R10.2
/P4.2: J2.3, R11.2
/P4.3: J2.4, R12.2
GND: J2.21, P5.5, P6.5, P7.3, R1.2, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R12.1
GNDPWR: J1.3, J1.6, J1.9, J1.12, P10.1, P10.2 (PM), Q1.S, Q2.S, Q3.S, Q4.S, Q5.S, Q6.S, Q7.S, Q8.S, R1.1
unnamed: J1.1, Q1.D
unnamed: J1.2, Q2.D
unnamed: J1.4, Q3.D
unnamed: J1.5, Q4.D
unnamed: J1.7, Q8.D
unnamed: J1.8, Q7.D
unnamed: J1.10, Q6.D
unnamed: J1.11, Q5.D
unnamed: P5.1, P6.1, P7.1
unnamed: P5.6, P6.6, R11.1
unnamed: P6.3, R10.1

Notes on the sheet:
R12 only populated if on left side of PSOC4200

Board: 2 copper layers, 50.0 x 65.0 mm, 32 parts (0 on the bottom side), 35 nets.

Other parts of the board:
VAL: REF; opp_logo_backsilk

## KiCad design Kicad/1020-IncandPlankG2/1020.kicad_pcb

Parts:
J1: Conn_01x22; Pin_Header_Straight_1x22_Pitch2.54mm
P1, P2: CONN_4X2; Pin_Header_Straight_2x04_Pitch2.54mm
P3: CONN_4; 00_th1x4x100-lock; Manufacturer PN 68001-436HLF
P4, P5, P6, P7: TST; 00_mtg_hole-2-56
P8, P9: CONN_8; 00_th1x8x100-lock
P10: CONN_2; 00_th1x2x4.2mm_cheap
P11: SPADE_187; 00_th1x2x200; Manufacturer PN 1285
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16: MOSFET_N; 00_to92_dgs; Manufacturer PN 2N7000TA
R1, R4: 0; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R2, R3: 480; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical

Connections:
+5V: J1.22, P1.7, P2.7, P3.4
+12V1: P1.8, P2.8
/P0.0: J1.5, Q16.G
/P0.1: J1.6, Q14.G
/P0.2: J1.7, Q12.G
/P0.3: J1.8, Q10.G
/P0.4: J1.9, Q8.G
/P0.5: J1.10, Q6.G
/P0.6: J1.11, Q4.G
/P0.7: J1.12, Q2.G
/P1.0: J1.13, Q1.G
/P1.1: J1.14, Q3.G
/P1.2: J1.15, Q5.G
/P1.3: J1.16, Q7.G
/P1.4: J1.17, Q9.G
/P1.5: J1.18, Q11.G
/P1.6: J1.19, Q13.G
/P1.7: J1.20, Q15.G
/P4.0: J1.1, P1.3, P3.2
/P4.1: J1.2, R3.2
/P4.2: J1.3, R2.2
/P4.3: J1.4, R1.2
GND: J1.21, P1.5, P2.5, P3.3, R1.1, R4.1
GNDPWR: P10.1, P10.2 (PM), P11.1, P11.2 (PM), Q1.S, Q2.S, Q3.S, Q4.S, Q5.S, Q6.S, Q7.S, Q8.S, Q9.S, Q10.S, Q11.S, Q12.S, Q13.S, Q14.S, Q15.S, Q16.S, R4.2
unnamed: P1.1, P2.1, P3.1
unnamed: P1.6, P2.6, R2.1
unnamed: P2.3, R3.1
unnamed: P8.1, Q1.D
unnamed: P8.2, Q3.D
unnamed: P8.3, Q5.D
unnamed: P8.4, Q7.D
unnamed: P8.5, Q9.D
unnamed: P8.6, Q11.D
unnamed: P8.7, Q13.D
unnamed: P8.8, Q15.D
unnamed: P9.1, Q16.D
unnamed: P9.2, Q14.D
unnamed: P9.3, Q12.D
unnamed: P9.4, Q10.D
unnamed: P9.5, Q8.D
unnamed: P9.6, Q6.D
unnamed: P9.7, Q4.D
unnamed: P9.8, Q2.D

Notes on the sheet:
R1 only populated if on left side of PSOC4200

Board: 2 copper layers, 50.0 x 65.0 mm, 33 parts (0 on the bottom side), 43 nets.

Other parts of the board:
VAL: REF; opp_logo_backsilk

## KiCad design Kicad/1017-IncandSMG2/1017.kicad_pcb

Parts:
P1, P3: CONN_4; Manufacturer PN 68001-436HLF
P2, P7: CONN_8
P4: SPADE_187; Manufacturer PN 1285
P5: CONN_2
P6: TST
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22, Q23, Q24: MOSFET_N; Manufacturer PN 2N7000TA
R1, R2, R3, R4, R5, R6, R7, R8: 10K

Connections:
+5V: P1.3, P3.3
+12V1: P1.2, P3.2, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2
+VLED: P1.1, P3.1, P4.1, P4.2, P5.1, P5.2 (PM), Q1.D, Q2.D, Q3.D, Q4.D, Q5.D, Q6.D, Q7.D, Q8.D, Q17.S, Q18.S, Q19.S, Q20.S, Q21.S, Q22.S, Q23.S, Q24.S
/P0: P2.1, Q9.G, Q17.G
/P1: P2.2, Q10.G, Q18.G
/P2: P2.3, Q11.G, Q19.G
/P3: P2.4, Q12.G, Q20.G
/P4: P2.5, Q13.G, Q21.G
/P5: P2.6, Q14.G, Q22.G
/P6: P2.7, Q15.G, Q23.G
/P7: P2.8, Q16.G, Q24.G
GND: P1.4, P3.4, Q9.S, Q10.S, Q11.S, Q12.S, Q13.S, Q14.S, Q15.S, Q16.S
unnamed: Q2.G, Q10.D, R2.1
unnamed: P7.8, Q8.S, Q24.D
unnamed: P7.7, Q7.S, Q23.D
unnamed: P7.6, Q6.S, Q22.D
unnamed: P7.5, Q5.S, Q21.D
unnamed: P7.4, Q4.S, Q20.D
unnamed: Q7.G, Q15.D, R7.1
unnamed: Q5.G, Q13.D, R5.1
unnamed: P7.2, Q2.S, Q18.D
unnamed: P7.1, Q1.S, Q17.D
unnamed: Q1.G, Q9.D, R1.1
unnamed: P7.3, Q3.S, Q19.D
unnamed: Q8.G, Q16.D, R8.1
unnamed: Q6.G, Q14.D, R6.1
unnamed: Q4.G, Q12.D, R4.1
unnamed: Q3.G, Q11.D, R3.1

Board: 2 copper layers, 44.4 x 20.3 mm, 40 parts (8 on the bottom side), 28 nets.

Other parts of the board:
VAL: REF; opp_logo_backsilk

## KiCad design Kicad/1014-IncandBrdG2/1014.kicad_pcb

Board: 2 copper layers, 44.4 x 20.3 mm, 24 parts (0 on the bottom side), 20 nets.

Parts:
P1: TST; 00_mtg_hole-2-56
P2, P3: CONN_4; SIL-4
P4: SPADE_187; 00_th1x2x200
P5: CONN_8; SIL-8
P6: CONN_2; 00_th1x2x4.2mm_cheap
P7: CONN_8; 00_th1x8x100-lock
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: MOSFET_N; 00_to92_sgd
R2, R3, R4, R5, R6, R7, R8, R9: 10K; R1
VAL: REF; opp_logo_backsilk

Connections:
+5V: P2.3, P3.3
+12V1: P2.2, P3.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2
+VLED: P2.1, P3.1, P4.1, P4.2, P6.1, P6.2, Q1.D, Q2.D, Q3.D, Q4.D, Q5.D, Q6.D, Q7.D, Q8.D
/P0: P5.1, Q1.G, R2.1
/P1: P5.2, Q2.G, R3.1
/P2: P5.3, Q3.G, R4.1
/P3: P5.4, Q4.G, R5.1
/P4: P5.5, Q5.G, R6.1
/P5: P5.6, Q6.G, R7.1
/P6: P5.7, Q7.G, R8.1
/P7: P5.8, Q8.G, R9.1
GND: P2.4, P3.4
unnamed: P7.3, Q3.S
unnamed: P7.1, Q1.S
unnamed: P7.2, Q2.S
unnamed: P7.4, Q4.S
unnamed: P7.5, Q5.S
unnamed: P7.6, Q6.S
unnamed: P7.7, Q7.S
unnamed: P7.8, Q8.S

## KiCad design Kicad/1018-PwrFilter/1018.kicad_pcb

Schematic: 1018.sch, Power Filter

Parts:
C1, C2, C3: CP1
D1, D2: LED
P1, P8, P9: CONN2X3MOLEX
P4, P7, P11, P12, P13, P14, P15, P16: TST
P10: CONN_6
Q1, Q2: MOSFET_P
R1, R2, R3, R6, R7, R8: 100K
R4, R5: 900K
TH1, TH2: THERMISTOR

Connections:
+48V1: P1.4, P1.5, P7.1, TH2.1
+48V2: P1.6, P4.1, TH1.1
GND1: C2.2, C3.2, D2.2 (K), P1.1, P1.2, P9.1, P9.2, P9.3, P10.1, P16.1, R8.1
GND2: C1.2, D1.2 (K), P1.3, P8.1, P8.2, P8.3, P10.6, P15.1, R7.1
unnamed: D2.1 (A), R6.1
unnamed: D1.1 (A), R3.1
unnamed: C1.1, Q1.S, R1.2, TH1.2
unnamed: P9.4, P9.5, P9.6, Q2.D, R5.2, R6.2
unnamed: P8.4, P8.5, P8.6, Q1.D, R3.2, R4.2
unnamed: P10.2, Q2.G, R2.1
unnamed: P10.5, Q1.G, R1.1
unnamed: P10.4, R4.1, R7.2
unnamed: P10.3, R5.1, R8.2
unnamed: C2.1, C3.1, Q2.S, R2.2, TH2.2

Board: 2 copper layers, 50.0 x 100.0 mm, 30 parts (0 on the bottom side), 14 nets.

Other parts of the board:
VAL: REF; opp_logo_backsilk

## KiCad design Kicad/1016-IntfBrdG2/1016.kicad_pcb

Parts:
P1: TST
P2, P3, P4, P7: CONN_4; Manufacturer PN 68001-436HLF
P5, P6: CONN_4X2
P8: CONN_3
P15: CONN_2
R1: 0
R2, R3: 480

Connections:
+5V: P2.3, P3.3, P5.7, P6.7, P7.4
+12V1: P2.2, P3.2, P5.8, P6.8, P15.1, P15.2 (PM)
/P0: P4.1, P5.3, P7.2
/P1: P4.2, R3.2
/P2: P4.3, R2.2
GND: P2.4, P3.4, P5.5, P6.5, P7.3, R1.1
GNDPWR: P2.1, P3.1, R1.2
unnamed: P6.3, P8.1, R3.1
unnamed: P7.1, P8.2 (PM)
unnamed: P5.1, P6.1, P8.3
unnamed: P5.6, P6.6, R2.1

Board: 2 copper layers, 43.2 x 15.2 mm, 13 parts (0 on the bottom side), 11 nets.

Other parts of the board:
VAL: REF; opp_logo_backsilk
